# Keil uVision project S15.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: S15 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c all.h ctrl.c ds1302.c smg.c time.c iic.c key.c
