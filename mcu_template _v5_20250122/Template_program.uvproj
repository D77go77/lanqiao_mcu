# Keil uVision project Template_program.uvproj, settings and files
target main (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Template_program +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Drivers;.\User
  group User
    ./User/: main.c all.h
    ./Drivers/: scheduler.c
  group Drivers
    ./Drivers/: ctrl.c iic.c key.c led.c onewire.c rtc.c smg.c time.c uart.c wave.c
